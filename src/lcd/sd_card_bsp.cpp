#include <stdio.h>
#include <string.h>
#include <Arduino.h>
#include <sys/unistd.h>
#include <sys/stat.h>
#include "esp_vfs_fat.h"
#include "sdmmc_cmd.h"
#include "driver/sdmmc_host.h"
#include "sd_card_bsp.h"
#include "driver/gpio.h"
#include "freertos/FreeRTOS.h"
#include "freertos/task.h"
#include "ff.h"

#define SDMMC_CMD_PIN   (gpio_num_t)3
#define SDMMC_D0_PIN    (gpio_num_t)5
#define SDMMC_D1_PIN    (gpio_num_t)6
#define SDMMC_D2_PIN    (gpio_num_t)42
#define SDMMC_D3_PIN    (gpio_num_t)2
#define SDMMC_CLK_PIN   (gpio_num_t)4
#define SDlist "/sdcard" //Directory, similar to a standard


sdmmc_card_t *card = NULL; //handle


void sd_card_Init(void)
{
  esp_vfs_fat_sdmmc_mount_config_t mount_config = 
  {
    .format_if_mount_failed = false,     //If the hook fails, create a partition table and format the SD car
    .max_files = 5,                      //Maximum number of open files
    .allocation_unit_size = 512,         //Similar to sector size
  };

  sdmmc_host_t host = SDMMC_HOST_DEFAULT();
  host.max_freq_khz = SDMMC_FREQ_HIGHSPEED;//high speed

  sdmmc_slot_config_t slot_config = SDMMC_SLOT_CONFIG_DEFAULT();
  slot_config.width = 4;           //4-wire
  slot_config.clk = SDMMC_CLK_PIN;
  slot_config.cmd = SDMMC_CMD_PIN;
  slot_config.d0 = SDMMC_D0_PIN;
  slot_config.d1 = SDMMC_D1_PIN;
  slot_config.d2 = SDMMC_D2_PIN;
  slot_config.d3 = SDMMC_D3_PIN;
  ESP_ERROR_CHECK_WITHOUT_ABORT(esp_vfs_fat_sdmmc_mount(SDlist, &host, &slot_config, &mount_config, &card));

  if(card != NULL)
  {
    sdmmc_card_print_info(stdout, card); //Print out the card information
    Serial.print("practical_size:");
    Serial.println(sd_card_get_value());//g
  }
}
float sd_card_get_value(void)
{
  if(card != NULL)
  {
    return (float)(card->csd.capacity)/2048/1024; //G
  }
  else
  return 0;
}

/*write data
path:path
data:data
*/
esp_err_t s_example_write_file(const char *path, char *data)
{
  esp_err_t err;
  if(card == NULL)
  {
    return ESP_ERR_NOT_FOUND;
  }
  err = sdmmc_get_status(card); //First check if there is an SD card
  if(err != ESP_OK)
  {
    return err;
  }
  FILE *f = fopen(path, "w"); //Get path address
  if(f == NULL)
  {
    printf("path:Write Wrong path\n");
    return ESP_ERR_NOT_FOUND;
  }
  fprintf(f, data); //write in
  fclose(f);
  return ESP_OK;
}
/*
read data
path:path
*/
esp_err_t s_example_read_file(const char *path,char *pxbuf,uint32_t *outLen)
{
  esp_err_t err;
  if(card == NULL)
  {
    printf("path:card == NULL\n");
    return ESP_ERR_NOT_FOUND;
  }
  err = sdmmc_get_status(card); //First check if there is an SD card
  if(err != ESP_OK)
  {
    printf("path:card == NO\n");
    return err;
  }
  FILE *f = fopen(path, "rb");
  if (f == NULL)
  {
    printf("path:Read Wrong path\n");
    return ESP_ERR_NOT_FOUND;
  }
  fseek(f, 0, SEEK_END);     //Move the pointer to the back
  uint32_t unlen = ftell(f);
  //fgets(pxbuf, unlen, f); //Read text
  fseek(f, 0, SEEK_SET); //Move the pointer to the front
  uint32_t poutLen = fread((void *)pxbuf,1,unlen,f);
  printf("pxlen: %ld,outLen: %ld\n",unlen,poutLen);
  //*outLen = poutLen;
  fclose(f);
  return ESP_OK;
}
// In sd_card_bsp.cpp
   // needed for FatFs structures

esp_err_t sd_card_list_files(const char *dirPath, uint8_t levels) {
    FRESULT res;
    FILINFO fno;
    FF_DIR dir;

    res = f_opendir(&dir, dirPath);  // Open directory
    if (res != FR_OK) {
        Serial.printf("Failed to open dir: %s (error: %d)\n", dirPath, res);
        return ESP_ERR_NOT_FOUND;
    }

    while (true) {
        res = f_readdir(&dir, &fno);  // Read a directory item
        if (res != FR_OK || fno.fname[0] == 0) break; // Break on error or end

        if (fno.fattrib & AM_DIR) {
            Serial.printf("[DIR]  %s\n", fno.fname);
            if (levels > 0) {
                // recurse into subdir
                String newPath = String(dirPath) + "/" + fno.fname;
                sd_card_list_files(newPath.c_str(), levels - 1);
            }
        } else {
            Serial.printf("[FILE] %s  (%lu bytes)\n", fno.fname, (uint32_t)fno.fsize);
        }
    }

    f_closedir(&dir);
    return ESP_OK;
}

esp_err_t sd_card_delete_file(const char *path)
{
    if (remove(path) == 0) {
        return ESP_OK;
    }
    return ESP_FAIL;
}
